{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_State :
(
	idle := 0,
	init,
	write,
	aggregation,
	readstruct,
	validationIssues,
	validationRemaining,
	error
	
	
	
);
END_TYPE
